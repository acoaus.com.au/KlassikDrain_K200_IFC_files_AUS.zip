Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: eb084157-b874-49a9-a16a-e96f7d606e19, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 145433.ifc
Time: 2026-02-16T17:26:19+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuildingStorey: Level:8mm Head (2)
Name | LongName | Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcFlowTerminal: PF_ST_KlassikDrain_K200 & KS200_channels_AUS_ACO:KlassikDrain_KS200_Invert_Depth_350mm to 400mm, PF_ST_KlassikDrain_K200 & KS200_channels_AUS_ACO:KlassikDrain_KS200_Invert_Depth_350mm to 400mm:399168
In: Level 1
Type - Description: ACO KlassikDrain K200/KS200 channels; PredefinedType: USERDEFINED; Material: Steel, Stainless, polymer concrete
KlassikDrain_K200 - code_supplier_article_C_ANZRS: 145433; item_description: KS2-33 Sloped channel - (1m); net_mass_S_ANZRS: 53.9 kg; LOD: LOD 300; Manufacturer: ACO

# IfcFlowTerminal: ZZZ_do not use_PF_ST_KlassikDrain_K200_gratings_ACO:std(nested), ZZZ_do not use_PF_ST_KlassikDrain_K200_gratings_ACO:std(nested):399172
In: Level 1
Type - Description: ACO Grating for KlassikDrain_K100; Material: Steel, Stainless
KlassikDrain_K200 - code_supplier_article_C_ANZRS: 142219; item_description: Type 647D Stainless Wedgewire Heelsafe® Anti-Slip grate (1m); net_mass_S_ANZRS: 7.5 kg; LOD: LOD 300; Manufacturer: ACO
