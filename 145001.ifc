Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: eb084157-b874-49a9-a16a-e96f7d606e19, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 145001.ifc
Time: 2026-02-16T15:45:50+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuildingStorey: Level:8mm Head (2)
Name | LongName | Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcFlowTerminal: PF_ST_KlassikDrain_K200 & KS200_channels_AUS_ACO:KlassikDrain_K200_Invert_Depth_200mm to 249mm, PF_ST_KlassikDrain_K200 & KS200_channels_AUS_ACO:KlassikDrain_K200_Invert_Depth_200mm to 249mm:399168
In: Level 1
Type - Description: ACO KlassikDrain K200/KS200 channels; PredefinedType: USERDEFINED; Material: Steel, Galvanised, polymer concrete
KlassikDrain_K200 - code_supplier_article_C_ANZRS: 145001; item_description: K2-1 Sloped channel – (1m); net_mass_S_ANZRS: 37.9 kg; LOD: LOD 300; Manufacturer: ACO

# IfcFlowTerminal: ZZZ_do not use_PF_ST_KlassikDrain_K200_gratings_ACO:std(nested), ZZZ_do not use_PF_ST_KlassikDrain_K200_gratings_ACO:std(nested):399172
In: Level 1
Type - Description: ACO Grating for KlassikDrain_K100; Material: Steel, Galvanised
KlassikDrain_K200 - code_supplier_article_C_ANZRS: 142405; item_description: Type 605Q Galvanised Mesh grate (1m); net_mass_S_ANZRS: 13.8 kg; LOD: LOD 300; Manufacturer: ACO
