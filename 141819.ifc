Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: eb084157-b874-49a9-a16a-e96f7d606e19, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 141819.ifc
Time: 2026-02-16T15:38:50+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuildingStorey: Level:8mm Head (2)
Name | LongName | Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcDistributionPort (15)
Description: Flow; FlowDirection: SOURCE
Name
OutPort_389594_1
OutPort_389594_2
OutPort_389594_3
OutPort_389594_4
OutPort_389594_5
OutPort_389594_6
OutPort_389594_7
OutPort_389594_8
OutPort_389594_9
OutPort_389594_10
OutPort_389594_11
OutPort_389594_12
OutPort_389594_13
OutPort_389594_14
OutPort_389594_15

# IfcFlowTerminal: KlassikDrain_K2-902G_In-line_pit:K2-902G In-line pit (0.5m), KlassikDrain_K2-902G_In-line_pit:K2-902G In-line pit (0.5m):389594
In: Level 1
Type - Description: ACO K2-902G In-line pit (0.5m); PredefinedType: USERDEFINED; Material: PE, Black, polymer concrete, Steel, Galvanised
KlassikDrain_K200 - code_supplier_article_C_ANZRS: 141819; item_description: ACO K2-902G In-line pit (0.5m); net_mass_S_ANZRS: 30.8 kg; Manufacturer: ACO

# IfcFlowTerminal: ZZZ_do not use_PF_ST_KlassikDrain_K200_in-line-pit__gratings_ACO:std(nested), ZZZ_do not use_PF_ST_KlassikDrain_K200_in-line-pit__gratings_ACO:std(nested):389596
In: Level 1
Type - Description: ACO Grating for KlassikDrain_K100; Material: Steel, Galvanised
KlassikDrain_K200 - code_supplier_article_C_ANZRS: 142483; item_description: Galvanised Double Brickslot 200 (0.5m); net_mass_S_ANZRS: 6.6 kg; LOD: LOD 300; Manufacturer: ACO
