Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: eb084157-b874-49a9-a16a-e96f7d606e19, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 96821.ifc
Time: 2026-02-16T17:35:06+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuildingStorey: Level:8mm Head (2)
Name | LongName | Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcFlowTerminal: ZZZ_do not use_PF_ST_KlassikDrain_K200_endcaps_ACO:std(nested), ZZZ_do not use_PF_ST_KlassikDrain_K200_endcaps_ACO:std(nested):402716
In: Level 1
Type - Description: ACO KlassikDrain K200 / KS200 Endcaps; PredefinedType: USERDEFINED; Material: grey ABS
KlassikDrain_K200 - code_supplier_article_C_ANZRS: 96821; item_description: K200/KS200 End cap; net_mass_S_ANZRS: 0.6 kg; Uniclass 2015 Code: Ss_50_30_02; Uniclass 2015 Title: Rainwater drainage systems; LOD: LOD 300; Manufacturer: ACO
